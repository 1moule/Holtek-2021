# Keil uVision project template-ploject.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template-ploject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\CORE;C:\Keil_v5\ARM\ARMCLANG\include;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\Utils;..\Gizwits;..\HARDWARE\DHT11;..\HARDWARE\PWM;..\HARDWARE\OLED;..\HARDWARE\SYSTICK;..\HARDWARE\BH1750;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\RCC;..\HARDWARE\IO;..\HARDWARE\WS2812B;..\HARDWARE\TIM2;..\STM32F10x_FWLIB\inc;..\Middlewares\LiteOS\arch\arm\arm-m\include;..\Middlewares\LiteOS\kernel\include;..\Middlewares\LiteOS\kernel\base\include;..\Middlewares\LiteOS\kernel\extended\include;..\OS_CONFIG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/SYSTICK/: bsp_systick.c
    ../HARDWARE/KEY/: bsp_key.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIM2/: TIM2.c
    ../HARDWARE/WS2812B/: WS2812B.c
    ../HARDWARE/IO/: IO.c
    ../HARDWARE/DMA/: DMA1.c
    ../HARDWARE/RCC/: RCC.c
  group Gizwits
    ../Gizwits/: gizwits_protocol.c gizwits_product.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
  group kernel
    ../Middlewares/LiteOS/kernel/: los_init.c
    ../Middlewares/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Middlewares/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Middlewares/LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../Middlewares/LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../Middlewares/LiteOS/kernel/base/mem/membox/: los_membox.c
    ../Middlewares/LiteOS/kernel/base/misc/: los_misc.c
    ../Middlewares/LiteOS/kernel/base/om/: los_err.c
    ../Middlewares/LiteOS/kernel/extended/tickless/: los_tickless.c
  group arch
    ../Middlewares/LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ../Middlewares/LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
